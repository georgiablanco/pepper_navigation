Commit message: 09/04

File: worlds/samurai_tables.urdf (robot description, URDF)
Before this commit: robot cube.urdf, 1 links, 0 joints
Links:
- link baseLink: geometry collision mesh filename=samurai_monastry.obj scale=0.8 0.8 0.8; visual mesh filename=samurai_monastry.obj scale=0.8 0.8 0.8
